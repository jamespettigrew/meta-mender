require u-boot-nanopi.inc
